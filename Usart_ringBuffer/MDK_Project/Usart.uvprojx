# Keil uVision project Usart.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Usart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Lib\inc;..\Lib\cmsis;..\user;..\Lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group lib
    ../Lib/cmsis/: core_cm3.c
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
  group user
    ../user/: main.c stm32f10x_it.c usart.c system_stm32f10x.c
  group start
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.2.0
